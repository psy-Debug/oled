# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\hardware;..\..\lib\CMSIS;..\..\lib\STM32F10x_StdPeriph_Driver\inc;..\..\lib\STM32F10x_StdPeriph_Driver\src;..\..\user;..\..\system;..\..\lib\CMSIS\startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group system
    ../../system/: Delay.c Delay.h delay1.c delay1.h Timer.c Timer.h usart.c usart.h
  group hardware
    ./hardware/: OLED.c OLED.h OLED_Data.c OLED_Data.h OLED_Font.h qmath.c qmath.h bmi088.c exti.c bmi088.h exti.h quat.c quat.h attitude.c attitude.h sensor_initial_alignment.h sensor_initial_alignment.c pid.c pid.h motor_mixer.c motor_mixer.h flight_controller.c flight_controller.h motor_pwm.c motor_pwm.h attitude_quat.c usart3.c attitude_quat.h usart3.h usart1.c usart1.h led.h led.c
  group startup
    ../../lib/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../../lib/CMSIS/startup/: startup_stm32f10x_md.s
  group user
    ../../user/: stm32f10x_conf.h stm32f10x_it.h stm32f10x_it.c
    ./: main.c
  group fwlib
    ../../lib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
